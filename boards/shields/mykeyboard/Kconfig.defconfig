## boards/shields/mykeyboard2/Kconfig.defconfig
```kconfig
if SHIELD_MYKEYBOARD2

config ZMK_KEYBOARD_NAME
    default "mykeyboard2"

endif
```
